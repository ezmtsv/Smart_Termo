# Keil uVision project Termo_with_boiler.uvprojx, settings and files
target Prj (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Termo_with_boiler +hex
  AfterMake: fromelf --bin --output .\Termo_boiler.bin .\Objects\Termo_with_boiler.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072,USE_USB_DEVICE_FS,INTERNAL_PULLUP,
  c include: .\ARM_ST\INC;.\Periph_drv\INC;.\USB_drv\INC;.\USB_lib\INC;.\USER\INC
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c4 size 0x3f40
  group ARM
    ./ARM_ST/SRC/: startup_stm32f072.s
  group Perif
    ./Periph_drv/SRC/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USB
    ./USB_drv/SRC/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./USB_lib/SRC/: usbd_core.c usbd_ioreq.c usbd_req.c
  group user
    ./USER/SRC/: func.c main.c stm32f0xx_it.c system_stm32f0xx.c TM1637.c usart_stm.c usb_bsp.c usbd_custom_hid_core.c usbd_desc.c usbd_pwr.c usbd_usr.c user_init.c wifi_esp8266.c
